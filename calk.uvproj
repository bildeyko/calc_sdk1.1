# Keil uVision project calk.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC812 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200) DPX
  output: calk +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 main.c fixedPoint.c mem_ops.c
