# Keil uVision project calk1.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC812 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200) DPX
  output: calk +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include_c51
  group Source Group 1
    ./src/: fixed_point_test.h fixedPoint.h mem_ops.h fixed_point_test.c fixedPoint.c main.c mem_ops.c calc.c kb.c lcd.c max.c START_AD.A51 calc.h kb.h lcd.h max.h
